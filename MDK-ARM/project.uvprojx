# Keil uVision project project.uvprojx, settings and files
target STM32F103RCT6_CarSeatWeigh_App (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: E:\Keil5\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Core\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\UserApp;..\Bsp;..\Bsp\ble_mcu_sdk;..\Math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1e800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STM32_STD
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Core
    ../Core/src/: main.c gpio.c usart.c adc.c tim.c can.c
  group Bsp
    ../Bsp/: stm32f1xx_std.c debug.c can_com.c store.c hx711.c
  group UserApp
    ../UserApp/: user_main.c user_it.c
  group Doc
    ../Doc/: readme.txt
